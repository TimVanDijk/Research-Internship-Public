# Keil uVision project OperationsInOddCharacteristicFields.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: ARMCM4 ARM
  pack: ARM.CMSIS.5.3.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M4") CLOCK(12000000) ESEL ELITTLE
  output: OperationsInOddCharacteristicFields
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group Source Group 1
    ./: wrapper.c F3_operations.s F5_operations.s F7_operations.s
software components: CMSIS:CORE 5.1.1, Device:Startup 1.0.1, Compiler:I/O:STDERR 1.4.0, Compiler:I/O:STDIN 1.4.0, Compiler:I/O:STDOUT 1.4.0
